<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x770B;&#x95e8;&#x72D7;&#x76D1;&#x6D4B;&#x7A0B;&#x5e8F;&#x8FD0;&#x884C;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


