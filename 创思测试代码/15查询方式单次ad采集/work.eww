<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x67e5;&#x8Be2;&#x65B9;&#x5F0F;&#x5355;&#x6B21;ad&#x91C7;&#x96C6;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


