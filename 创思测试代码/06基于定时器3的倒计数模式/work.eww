<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x57FA;&#x4e8e;&#x5B9A;&#x65F6;&#x5668;3&#x7684;&#x5012;&#x8BA1;&#x6570;&#x6A21;&#x5F0F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


