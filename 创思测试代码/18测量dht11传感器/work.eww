<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6e29;&#x6e7F;&#x5eA6;&#x6D4B;&#x91CF;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


