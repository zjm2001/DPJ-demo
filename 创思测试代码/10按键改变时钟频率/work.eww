<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6309;&#x952e;&#x6539;&#x53D8;&#x65F6;&#x949F;&#x9891;&#x7387;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


