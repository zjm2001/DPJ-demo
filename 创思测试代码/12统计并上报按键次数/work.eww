<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x7eDF;&#x8BA1;&#x4e0A;&#x62A5;&#x6309;&#x952e;&#x6B21;&#x6570;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


