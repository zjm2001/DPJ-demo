<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x4e24;&#x8DeF;&#x91C7;&#x96C6;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


