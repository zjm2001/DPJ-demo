<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x4e32;&#x53e3;&#x6536;&#x53D1;&#x57FA;&#x7840;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


