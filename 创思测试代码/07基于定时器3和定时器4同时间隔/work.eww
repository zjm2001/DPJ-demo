<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x57FA;&#x4e8e;&#x5B9A;&#x65F6;&#x5668;3&#x548C;&#x5B9A;&#x65F6;&#x5668;4&#x76F8;&#x540C;&#x65F6;&#x95F4;&#x95F4;&#x9694;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


