<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x4e32;&#x53e3;&#x63A7;&#x5236;&#x706F;&#x5149;&#x5F00;&#x5173;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


