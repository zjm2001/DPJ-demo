<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5916;&#x90e8;&#x4e2D;&#x65AD;&#x63A7;&#x5236;&#x8DD1;&#x9A6C;&#x706F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


