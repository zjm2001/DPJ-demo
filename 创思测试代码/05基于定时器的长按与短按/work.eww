<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x57FA;&#x4e8e;&#x5B9A;&#x65F6;&#x5668;&#x7684;&#x957F;&#x6309;&#x4e0e;&#x77eD;&#x6309;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


