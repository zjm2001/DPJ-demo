<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5B9A;&#x65F6;&#x5668;&#x4e00;&#x7684;&#x6A21;&#x6A21;&#x5F0F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


