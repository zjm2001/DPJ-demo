<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x770B;&#x95e8;&#x72D7;&#x5B9A;&#x65F6;&#x5668;&#x5B9e;&#x73B0;&#x4e00;&#x79D2;&#x5B9A;&#x65F6;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


