<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\D4&#x706F;&#x5149;&#x5FAA;&#x95eA;&#x70C1;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


