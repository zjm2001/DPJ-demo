<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6D4B;&#x8BD5;&#x4e32;&#x53e3;&#x4e0A;&#x4F20;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


