<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6309;&#x952e;&#x63A7;&#x5236;&#x6682;&#x505C;&#x4e0e;&#x8FD0;&#x884C;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


