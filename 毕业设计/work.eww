<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6D4B;&#x8BD5;&#x4ee3;&#x7801;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


