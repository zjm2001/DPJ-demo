<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5355;&#x6309;&#x94Ae;&#x63A7;&#x5236;&#x706F;&#x5149;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


