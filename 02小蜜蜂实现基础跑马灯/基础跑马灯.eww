<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x57FA;&#x7840;&#x8DD1;&#x9A6C;&#x706F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


